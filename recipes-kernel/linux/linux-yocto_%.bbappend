FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}"

SRC_URI += "file://kdump.cfg"
